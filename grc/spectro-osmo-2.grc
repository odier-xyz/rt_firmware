options:
  parameters:
    author: Jérôme Odier
    description: https://www.odier.xyz/
    generate_options: no_gui
    id: spectro_osmo_2
    output_language: python
    title: Spectro OsmoSDR
  states: {}

blocks:
- name: bandwidth
  id: parameter
  parameters:
    type: eng_float
    value: 2e6
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_correctiq_0_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: float
    vlen: fft_bins
  states: {}
- name: blocks_streams_to_vector_0_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '''tcp://*:{}''.format(port2)'
    timeout: '100'
    type: float
    vlen: 2 * fft_bins
  states: {}
- name: blocks_zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: '''tcp://*:{}''.format(port1)'
    timeout: '100'
    type: complex
    vlen: '2'
  states: {}
- name: clk_src
  id: parameter
  parameters:
    type: str
    value: internal
  states: {}
- name: fft_bins
  id: parameter
  parameters:
    type: intx
    value: '2048'
  states: {}
- name: frequency
  id: parameter
  parameters:
    type: eng_float
    value: 1420e6
  states: {}
- name: int_time
  id: parameter
  parameters:
    type: intx
    value: '1'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bb_gain1: '20'
    bw0: bandwidth
    clock_source0: clk_src
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: frequency
    freq1: frequency
    gain0: rx_gain
    gain1: rx_gain
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: bandwidth
    sync: sync
    type: fc32
  states: {}
- name: port1
  id: parameter
  parameters:
    type: intx
    value: '50001'
  states: {}
- name: port2
  id: parameter
  parameters:
    type: intx
    value: '50002'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '30'
  states: {}
- name: spectro_0
  id: spectro
  parameters:
    bandwidth: bandwidth
    fft_bins: fft_bins
    int_time: int_time
  states: {}
- name: spectro_0_0
  id: spectro
  parameters:
    bandwidth: bandwidth
    fft_bins: fft_bins
    int_time: int_time
  states: {}

connections:
- [blocks_correctiq_0, '0', blocks_streams_to_vector_0_0, '0']
- [blocks_correctiq_0, '0', spectro_0, '0']
- [blocks_correctiq_0_0, '0', blocks_streams_to_vector_0_0, '1']
- [blocks_correctiq_0_0, '0', spectro_0_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_zeromq_pub_sink_0, '0']
- [blocks_streams_to_vector_0_0, '0', blocks_zeromq_pub_sink_0_0, '0']
- [osmosdr_source_0, '0', blocks_correctiq_0, '0']
- [osmosdr_source_0, '1', blocks_correctiq_0_0, '0']
- [spectro_0, '0', blocks_streams_to_vector_0, '0']
- [spectro_0_0, '0', blocks_streams_to_vector_0, '1']

metadata:
  file_format: 1
