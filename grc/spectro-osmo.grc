options:
  parameters:
    generate_options: no_gui
    id: spectro_osmo
    output_language: python
    title: Spectro OsmoSDR
  states: {}

blocks:
- name: bandwidth
  id: parameter
  parameters:
    type: eng_float
    value: 2e6
  states: {}
- name: blocks_zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:50001
    timeout: '100'
    type: float
    vlen: channels
  states: {}
- name: channels
  id: parameter
  parameters:
    type: intx
    value: '4096'
  states: {}
- name: correctiq_correctiq_0
  id: correctiq_correctiq
  parameters: {}
  states: {}
- name: frequency
  id: parameter
  parameters:
    type: eng_float
    value: 1420e6
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: frequency
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: bandwidth
    sync: sync
    type: fc32
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '30'
  states: {}
- name: spectro_0
  id: spectro
  parameters:
    bandwidth: frequency
    channels: channels
    t_sample: '1'
  states: {}
- name: t_sample
  id: parameter
  parameters:
    type: intx
    value: '1'
  states: {}

connections:
- [correctiq_correctiq_0, '0', spectro_0, '0']
- [osmosdr_source_0, '0', correctiq_correctiq_0, '0']
- [spectro_0, '0', blocks_zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
