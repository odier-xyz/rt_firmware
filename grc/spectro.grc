options:
  parameters:
    author: Jérôme Odier
    category: '[odier.xyz]'
    description: https://www.odier.xyz/
    generate_options: hb
    id: spectro
    output_language: python
    title: Spectrometer
  states: {}

blocks:
- name: custom_window
  id: variable
  parameters:
    value: sinc * np.hamming(4 * fft_bins)
  states: {}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations / np.pi)
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-4.0 * np.pi / 2.0, +4.0 * np.pi / 2.0, np.pi / fft_bins)
  states: {}
- name: bandwidth
  id: parameter
  parameters:
    type: eng_float
    value: 2e6
  states: {}
- name: blocks_add_vcc_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
    vlen: fft_bins
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_bins
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fft_bins * 0
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: fft_bins * 1
    type: complex
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: fft_bins * 2
    type: complex
  states: {}
- name: blocks_delay_3
  id: blocks_delay
  parameters:
    delay: fft_bins * 3
    type: complex
  states: {}
- name: blocks_fft_vcc_0
  id: fft_vxx
  parameters:
    fft_size: fft_bins
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_bins)
  states: {}
- name: blocks_integrate_ff_0
  id: blocks_integrate_xx
  parameters:
    decim: int(int_time * bandwidth / fft_bins)
    type: float
    vlen: fft_bins
  states: {}
- name: blocks_multiply_const_vcc_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 'custom_window[-fft_bins: ]'
    type: complex
    vlen: fft_bins
  states: {}
- name: blocks_multiply_const_vcc_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 'custom_window[2 * fft_bins: 3 * fft_bins]'
    type: complex
    vlen: fft_bins
  states: {}
- name: blocks_multiply_const_vcc_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 'custom_window[1 * fft_bins: 2 * fft_bins]'
    type: complex
    vlen: fft_bins
  states: {}
- name: blocks_multiply_const_vcc_3
  id: blocks_multiply_const_vxx
  parameters:
    const: 'custom_window[: +fft_bins]'
    type: complex
    vlen: fft_bins
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_bins
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_bins
    type: complex
  states: {}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_bins
    type: complex
  states: {}
- name: blocks_stream_to_vector_3
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_bins
    type: complex
  states: {}
- name: fft_bins
  id: parameter
  parameters:
    type: intx
    value: '2048'
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: int_time
  id: parameter
  parameters:
    type: intx
    value: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: fft_bins
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [blocks_add_vcc_0, '0', blocks_fft_vcc_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_ff_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_delay_1, '0', blocks_stream_to_vector_2, '0']
- [blocks_delay_2, '0', blocks_stream_to_vector_1, '0']
- [blocks_delay_3, '0', blocks_stream_to_vector_3, '0']
- [blocks_fft_vcc_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_integrate_ff_0, '0', pad_sink_0, '0']
- [blocks_multiply_const_vcc_0, '0', blocks_add_vcc_0, '0']
- [blocks_multiply_const_vcc_1, '0', blocks_add_vcc_0, '1']
- [blocks_multiply_const_vcc_2, '0', blocks_add_vcc_0, '2']
- [blocks_multiply_const_vcc_3, '0', blocks_add_vcc_0, '3']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vcc_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_multiply_const_vcc_2, '0']
- [blocks_stream_to_vector_2, '0', blocks_multiply_const_vcc_1, '0']
- [blocks_stream_to_vector_3, '0', blocks_multiply_const_vcc_3, '0']
- [pad_source_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', blocks_delay_1, '0']
- [pad_source_0, '0', blocks_delay_2, '0']
- [pad_source_0, '0', blocks_delay_3, '0']

metadata:
  file_format: 1
